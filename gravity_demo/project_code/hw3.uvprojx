# Keil uVision project hw3.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hw3
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../Source_Code/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h Retarget.c Serial.c Serial.h
    ../source_code/: display_engine.c display_engine.h main.c director.c director.h timer.c timer.h sound.c sound.h
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.1.0, Device:Startup 1.0.0
