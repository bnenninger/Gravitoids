# Keil uVision project asteroids.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: asteroids
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../source_code/: AsciiLib.c AsciiLib.h director.c director.h framebuffer.c framebuffer.h GLCD.c GLCD.h i2c.c i2c.h joystick.c joystick.h main.c nunchuck.c nunchuck.h Retarget.c Serial.c Serial.h sound.c sound.h timer.c timer.h vector.c vector.h vector_render_engine.c vector_render_engine.h
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.1.0, Device:Startup 1.0.0
